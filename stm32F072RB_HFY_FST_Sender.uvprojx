# Keil uVision project stm32F072RB_HFY_FST_Sender.uvprojx, settings and files
target STM32F072RB (6220000::V6.22::ARMCLANG)
  device: STM32F072RBTx STMicroelectronics
  pack: Keil.STM32F0xx_DFP.3.1.1
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0x08000000-0x0801FFFF) CPUTYPE("Cortex-M0") CLOCK(8000000) ELITTLE
  output: stm32F072RB_HFY_FST_Sender +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: STM32F072xB
  c include: C:\Users\alexa\AppData\Local\Arm\Packs\ARM\CMSIS\6.3.0\CMSIS\Core\Include;C:\Users\alexa\AppData\Local\Arm\Packs\Keil\NUCLEO-F072RB_BSP\1.1.0\Examples\Blinky\STM32CubeMX\NUCLEO-F072RB\STM32CubeMX\Drivers\CMSIS\Device\ST\STM32F0xx\Include
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  scatter file: STM32F072RB.sct
  group Application
    Core/Src/: main.c
    Core/Startup/: startup_stm32f072xb.s
software components: CMSIS:CORE 6.2.0
